/************************************************************************************
Copyright (c) 2023-2025 released WuXi Indie Microelectronics Ltd.     All rights reserved.

WuXi Indie Microelectronics Ltd licenses to you the right to use, modify, copy and distribute
Software only when embedded on a WuXi Indie Microelectronics Ltd's microcontroller or digital signal
controller  that is integrated into your product or third party product

SOFTWARE AND DOCUMENTATION ARE PROVIDED "AS IS" WITHOUT WARRANTY OF ANY KIND,
EITHER EXPRESS OR IMPLIED, INCLUDING WITHOUT LIMITATION, ANY WARRANTY OF
MERCHANTABILITY, TITLE, NON-INFRINGEMENT AND FITNESS FOR A PARTICULAR PURPOSE.
IN NO EVENT SHALL WUXI INDIE MICROELECTRONICS LTD OR ITS LICENSORS BE LIABLE OR OBLIGATED UNDER
CONTRACT, NEGLIGENCE, STRICT LIABILITY, CONTRIBUTION, BREACH OF WARRANTY, OR
OTHER LEGAL EQUITABLE THEORY ANY DIRECT OR INDIRECT DAMAGES OR EXPENSES
INCLUDING BUT NOT LIMITED TO ANY INCIDENTAL, SPECIAL, INDIRECT, PUNITIVE OR
CONSEQUENTIAL DAMAGES, LOST PROFITS OR LOST DATA, COST OF PROCUREMENT OF
SUBSTITUTE GOODS, TECHNOLOGY, SERVICES, OR ANY CLAIMS BY THIRD PARTIES
(INCLUDING BUT NOT LIMITED TO ANY DEFENSE THEREOF), OR OTHER SIMILAR COSTS.
*************************************************************************************/

#include <taskManager.h>

#include <SoftTimerTask.h>
#include <colorMixingTask.h>
#include <applicationTask.h>
#include <linslaveTask.h>
#include <pdsTask.h>
#include <linmasterTask.h>
#include <linStackTask.h>
#include <measureTask.h>
#include <colorCompensationTask.h>
#include <safetyMonitorTask.h>
#include <wdt_device.h>

static volatile uint16_t taskFlags = 0U;
static uint16_t tasksMask = 0xFFFFU;
void IdleTask(void);

typedef void (*taskHandler_t)(void);

static taskHandler_t taskHandlers[] = {
    [TASK_ID_SOFT_TIMER]        = SoftTimer_TaskHandler,/* Global Timer task */
    [TASK_ID_LIN_STACK]         = LinStack_TaskHandler, /*  LIN stack task   */
    [TASK_ID_LINS]              = LINS_TaskHandler,     /*  LIN Slave task   */
    [TASK_ID_PDS]               = PDS_TaskHandler,      /*!< Task ID of persistance data storage*/
#if LIN_MASTER_EN == 1U
    [TASK_ID_LINM]              = LINM_TaskHandler,     /*  LIN Master task */
#endif
    [TASK_ID_COLOR_MIXING]      = CLM_TaskHandler,      /*  Color mixing and control task*/
    [TASK_ID_ADC_MEASURE]       = MES_TaskHandler,      /* ADC measurement, chip temperature, Led PN volt, Battery Volt etc. */
    [TASK_ID_SAFETY_MONITOR]    = SAFM_TaskHandler,     /* safe monitor task */
    [TASK_ID_COLOR_COMPENSATION]= CCP_TaskHandler,      /*  Color compensation task      */
    [TASK_ID_APPL]              = APPL_TaskHandler,     /*  design for debug and demo    */
};

void IdleTask(void)
{
    
  
}

void TM_RunTasks(void)
{
    uint8_t taskId;
    for (taskId = 0U; taskId < (uint8_t)(sizeof(taskHandlers) / sizeof(taskHandlers[0])); taskId++){
        if ( (((uint16_t)1UL << taskId) & (taskFlags & tasksMask)) != 0U ){
            __atomic_enter()
                taskFlags &= ~((uint16_t)1UL << taskId);
            __atomic_exit()
            if (taskHandlers[taskId] != NULL){
                taskHandlers[taskId]();
            }
            break;
        }
    }
    
#if WATCH_DOG_EN == 1U
    WDTA_Clear(); /* Feeding Watch dog */
#endif
    
    if (taskFlags == 0U){
        IdleTask();
    }
}

/*
 *  Disables specified task.
 *  @param [in] taskId - task to be disabled.
 *  @return none
 */
void TM_DisableTask(TM_TaskId_t taskId)
{
    tasksMask &= ~(uint16_t)(1UL << taskId);
}

/*
 *  brief Enables specified task.
 *  @param [in] taskId - task to be enabled.
 *  @return none
 */
void TM_EnableTask(TM_TaskId_t taskId)
{
    tasksMask |= (uint16_t)(1UL << taskId);
}

/*
 *  brief runs specified task.
 *  @param [in] taskId - task to be run.
 *  @return none
 */
void TM_PostTask(TM_TaskId_t taskId)
{
    __atomic_enter()
      taskFlags |= (uint16_t)(1UL << taskId);
    __atomic_exit()
}

uint8_t TM_TaskIsPending(TM_TaskId_t taskId)
{
    uint16_t flags =  taskFlags;
    uint16_t tasks = (uint16_t)1U << taskId;
    if ( (tasks & flags)!= 0U ){
        return 1U;
    }else{
        return 0U;
    }   
}