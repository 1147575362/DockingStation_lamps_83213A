# IAR project application.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: IND83213 IND83213
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __CHECK_DEVICE_DEFINES
  ICCARM.CCIncludePath2: drivers; drivers\studio; drivers\core\inc; drivers\hal\inc; drivers\hdf; drivers\hdf\sfrs; drivers\hwcfg\inc; Function_Blocks\ColorMixingTask; usr\common; usr\library; usr\leds; $TOOLKIT_DIR$\CMSIS\Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rugbyHP_cs01_app.bin
  ILINK.IlinkOutputFile: rugbyHP_cs01_app.out
  ILINK.IlinkIcfFile: rugbyHP_cs01_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    usr/: main.c
  group applications/config
    usr/common/: appConfig.h
  group applications/include
    usr/common/: applicationTask.h colorCompensationTask.h isrfuncs.h linMasterTask.h linSlaveTask.h linsNodeCfgIdentify.h measureTask.h pdsTask.h safetyMonitorTask.h systemInit.h taskManager.h
    Function_Blocks/ColorMixingTask/: colorFormula.h
    usr/library/: colorMixingTask.h linStackTask.h softTimerTask.h
  group applications/src
    usr/common/: applicationTask.c colorCompensationTask.c linMasterTask.c linslaveTask.c linslaveTask_J2602.c linslaveTask_Private.c linsNodeCfgIdentify.c linsNodeCfgIdentify_J2602.c measureTask.c measureTask_time_division_multiplex.c pdsTask.c safetyMonitorTask.c
  group crc/include
    usr/common/: crc32.h
  group crc/src
    usr/common/: crc32.c
  group drivers/core/inc
    drivers/core/inc/: flash_sfrs.h systick_sfrs.h verne.h
  group drivers/core/src
    drivers/core/src/: cstartup_M.c low_level_init.c
  group drivers/hal/inc
    drivers/hal/inc/: adc_device.h atomic.h buck_device.h clock_device.h errno.h flash_device.h gpio_device.h hwProtection.h lin_device.h pmu_device.h pwm_device.h pwmAux_device.h spi_device.h systick_device.h timer_device.h uart_device.h wdt_device.h
    usr/library/: buckOperation.h
  group drivers/hal/src
    drivers/hal/src/: adc_device_time_division_multiplex.c buck_device.c clock_device.c flash_device.c gpio_device.c hwProtection.c lin_device.c pmu_device.c pwm_device.c pwm_device_2_time_division_multiplex.c pwm_device_3_time_division_multiplex.c pwm_device_4_time_division_multiplex.c pwm_device_5_time_division_multiplex.c pwmAux_device.c spi_device.c systick_device.c timer_device.c uart_device.c wdt_device.c
    usr/library/: BuckOperation.a
  group drivers/hdf/inc
    drivers/hdf/sfrs/: bte_sfr.h crga_sfr.h evthold_sfr.h flash_sfr.h gpio_sfr.h ioctrla_sfr.h linm_sfr.h lins_sfr.h pmua_sfr.h pwm_aux_sfr.h pwm_sfr.h rugbyHP_sfrs.h spi_sfr.h sysctrla_sfr.h timer0_sfr.h timer1_sfr.h timer2_sfr.h uart_sfr.h wdt1_sfr.h wdta_sfr.h wica_sfr.h
    drivers/hdf/: rugbyHP.h
  group drivers/hwcfg/inc
    drivers/hwcfg/inc/: hwcfg.h
  group drivers/hwcfg/src
    drivers/hwcfg/src/: hwcfg.c
  group drivers/studio
    drivers/studio/: getchar.c putchar.c
  group library
    usr/library/: ColorMixingTask_RugbyHP_CS01.a LinStackTask_RugbyHP_CS01.a SoftTimerTask_RugbyHP_CS01.a
  group library/LedParamTables
    Function_Blocks/LedLibrary/: LedParamTables_67-63-RGB0201H-AM_V4  RGB.c LedParamTables_6SC3433VGB00MSZ3.c LedParamTables_BOS-3433RGB.c LedParamTables_Brightek_6SC3433VGB00MSZ3.c LedParamTables_BYD_BOS_3433RGB.c LedParamTables_CoAsia_IWS_E3536_BGR_K3.c LedParamTables_D6RTB-SKG.c LedParamTables_DOMINANT_D6RTB_HKG_CS1124.c LedParamTables_DOMINANT_D6RTB_SKG.c LedParamTables_DOMINANT_S6RTB_THG_3030.c LedParamTables_DOMINANT_SKRTB_FHG_2120.c LedParamTables_Everlight_67_63_RGB0201H_AM.c LedParamTables_Hongbright_H3433AVGB03Z04.c LedParamTables_Hongbright_H4516BVGB00Z01.c LedParamTables_IWS-E3536-BGR-K3_(1.0)_200203.c LedParamTables_OSRAM_E5515_GVSG.c LedParamTables_osram_e5515_gvsr.c LedParamTables_OSRAM_LRTB_GVSG.c LedParamTables_OSRAM_LRTB_GVSR.c LedParamTables_SEOUL_STF0A36ZA.c LedParamTables_SEOUL_STF0A36ZA_B.c LedParamTables_SKRTB-FHG_2120.c LedParamTables_SpicePlus 3030 Multi Color S6RTB-THG - v1.c LedParamTables_SpicePlus_3030_S6RTB_THG.c LedParamTables_STF0A36ZA.c
  group tasks
    usr/common/: systemInit.c taskManager.c
  group validation
    usr/common/: validation.c validation.h
